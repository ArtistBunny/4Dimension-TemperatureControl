# Keil uVision project ArtistBunny.uvprojx, settings and files
target ArtistBunny (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ArtistBunny +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\LIB\inc;.\SRC
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group lib3.5
    ./LIB/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_dma.c
  group startup
    ./LIB/src/: system_stm32f10x.c core_cm3.c
    ./LIB/Startup/: startup_stm32f10x_hd.s
  group src
    ./SRC/: Init.c Fun.c Main.c
